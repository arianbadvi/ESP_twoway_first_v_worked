<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\sen_rX_TX_interrupt.ewp</path>
  </project>
  <batchBuild />
</workspace>
